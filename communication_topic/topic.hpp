/**
 * @file topic.hpp
 * @brief Topic 系统核心实现（Topic/RingTopic/Subscription/Notifier integration）
 *
 * 本文件包含该模块的详细设计说明、内存序语义与使用示例。
 * 建议同时阅读 communication_topic/CommunicationTopic.md。
 */

#pragma once

#include <atomic>
#include <cstdint>
#include <cstring>

#include "topic_notify.hpp"

/*******************************************************************************
 * ============================================================================
 *                         消息通信模块 (Topic System)
 * ============================================================================
 *
 * 【模块概述】
 * ----------------------------------------------------------------------------
 * 本模块实现了一个轻量级的发布-订阅 (Pub-Sub) 消息通信框架，设计灵感来自于
 * PX4 飞控的 uORB (micro Object Request Broker) 系统。
 *
 * 适用场景：
 *   - RTOS 嵌入式系统中的模块间通信
 *   - 多任务/多线程环境下的数据共享
 *   - 传感器数据发布、控制指令下发等典型机器人应用
 *
 * 【设计目标】
 * ----------------------------------------------------------------------------
 * 1. 低延迟：无锁设计，避免互斥锁带来的优先级反转和阻塞
 * 2. 低开销：静态内存分配，无动态内存，适合资源受限的嵌入式系统
 * 3. 解耦合：发布者和订阅者相互独立，通过 Topic 进行间接通信
 * 4. 灵活性：支持单缓冲和环形缓冲两种模式，适应不同场景
 *
 * 【核心概念】
 * ----------------------------------------------------------------------------
 *
 * 1. Topic（主题）
 *    - 一个静态的全局共享数据容器
 *    - 包含数据缓冲区 + Generation 计数器
 *    - 类似于一个"公告板"，发布者写入，订阅者读取
 *
 * 2. Generation（世代/版本号）
 *    - 一个递增的计数器，每次 publish 后 +1
 *    - 订阅者通过比较 generation 判断数据是否更新
 *    - 这是实现无锁同步的关键机制
 *
 * 3. Publisher（发布者）
 *    - 负责产生数据并发布到 Topic
 *    - 一个 Topic 通常只有一个发布者（单写者模型）
 *
 * 4. Subscriber（订阅者）
 *    - 从 Topic 读取数据
 *    - 一个 Topic 可以有多个订阅者（多读者模型）
 *    - 每个订阅者独立追踪自己的读取进度
 *
 * 【内存序 (Memory Order) 说明】
 * ----------------------------------------------------------------------------
 * 本模块使用 C++11 原子操作配合特定的内存序，保证多线程环境下的正确性：
 *
 *   Release-Acquire 语义：
 *   +---------------------------------------------------------------------+
 *   |  Publisher (Thread A)           |  Subscriber (Thread B)           |
 *   |---------------------------------|----------------------------------|
 *   |  buffer_ = data;                |                                  |
 *   |  (写入数据)                      |                                  |
 *   |  generation_.fetch_add(1,       |                                  |
 *   |        memory_order_release) ---|--- synchronizes-with ----------> |
 *   |                                 |  gen = generation_.load(         |
 *   |                                 |        memory_order_acquire)     |
 *   |                                 |  (保证看到 buffer_ 的写入)         |
 *   |                                 |  out = buffer_;                  |
 *   +---------------------------------------------------------------------+
 *
 *   - release: 保证此操作之前的所有写入对其他线程可见
 *   - acquire: 保证此操作之后的所有读取能看到配对 release 之前的写入
 *
 * 【数据流示意图】
 * ----------------------------------------------------------------------------
 *
 *   +--------------+     publish()     +-------------+     copy()     +--------------+
 *   |  Publisher   | ----------------> |    Topic    | <------------- |  Subscriber  |
 *   |  (生产者)    |                   |  (共享缓冲)  |                |  (消费者)     |
 *   +--------------+                   +-------------+                +--------------+
 *                                            ^
 *                                            | copy()
 *                                      +--------------+
 *                                      |  Subscriber  |
 *                                      |  (消费者 2)   |
 *                                      +--------------+
 *
 * 【使用模式】
 * ----------------------------------------------------------------------------
 *
 * 模式 1: 只关心最新数据 (Topic<T>)
 *   - 订阅者只需要最新的一个数据
 *   - 适用于：状态信息、控制指令等
 *   - 如果订阅者读取太慢，中间数据会被覆盖（这是期望的行为）
 *
 * 模式 2: 需要历史数据 (RingTopic<T, DEPTH>)
 *   - 订阅者需要按顺序处理每一条数据
 *   - 使用环形缓冲区保存最近 DEPTH 条记录
 *   - 适用于：IMU 数据、编码器数据等需要积分/累加的场景
 *
 ******************************************************************************/

/*******************************************************************************
 * Topic<T> - 基础的单缓冲主题
 * ----------------------------------------------------------------------------
 *
 * 【功能】
 *   最简单的 Topic 实现，只保存最新的一条数据。
 *
 * 【内部结构】
 *   +----------------------------------------+
 *   |  Topic<T>                              |
 *   |  +----------------------------------+  |
 *   |  |  buffer_ : T                     |  |  <- 存储最新数据
 *   |  +----------------------------------+  |
 *   |  +----------------------------------+  |
 *   |  |  generation_ : atomic<uint32_t>  |  |  <- 版本计数器
 *   |  +----------------------------------+  |
 *   +----------------------------------------+
 *
 * 【线程安全性】
 *   - 单写者 (Single Writer): 安全
 *   - 多写者 (Multiple Writers): 不安全！数据可能撕裂
 *   - 多读者 (Multiple Readers): 安全（每个读者独立）
 *
 * 【注意事项】
 *   - 如果 T 是大型结构体，在读取过程中可能被写者覆盖（撕裂读取）
 *   - 对于简单的 POD 类型通常没问题
 *   - 对于大型或复杂结构体，考虑使用 RingTopic 或添加互斥保护
 *
 * 【使用示例】
 *   // 定义 Topic（通常在头文件中作为全局变量）
 *   inline Topic<MotorCmd> motor_cmd;
 *
 *   // 发布者
 *   MotorCmd cmd = {.duty = {0.5f, 0.5f, 0.5f, 0.5f}};
 *   motor_cmd.publish(cmd);
 *
 *   // 订阅者
 *   Subscription<MotorCmd> sub(motor_cmd);
 *   MotorCmd received;
 *   if (sub.copy(received)) {
 *       // 处理新数据
 *   }
 *
 ******************************************************************************/
template<typename T>
class Topic {
public:
    constexpr Topic() : generation_(0) {}

    /***************************************************************************
     * publish - 发布新数据
     * -------------------------------------------------------------------------
     * 【执行流程】
     *   1. 将数据拷贝到内部缓冲区 buffer_（非原子操作）
     *   2. 使用 fetch_add + memory_order_release 增加 generation
     *
     * 【内存序说明】
     *   memory_order_release 确保：
     *   - 步骤 1 的写入在步骤 2 之前完成（编译器/CPU 不会重排序）
     *   - 其他线程在看到新的 generation 时，一定能看到 buffer_ 的更新
     *
     * 【线程安全】
     *   - 仅支持单写者！如果多个线程同时 publish，数据会损坏
     *   - 如果需要多写者，请在外部加锁或使用其他机制
     *
     * @param data 要发布的数据（按引用传递，避免拷贝）
     **************************************************************************/
    inline void publish(const T& data)
    {
        buffer_ = data;  // Step 1: 写入数据（非原子）
        generation_.fetch_add(1, std::memory_order_release);  // Step 2: 发布（release 语义）

        // Step 3: 可选的 RTOS 通知（用于事件驱动）
        if (notifier_) {
            notifier_->notify();
        }
    }

    /***************************************************************************
     * generation - 获取当前版本号
     * -------------------------------------------------------------------------
     * 【用途】
     *   订阅者使用此函数检查是否有新数据
     *
     * 【内存序说明】
     *   memory_order_acquire 确保：
     *   - 如果看到了新的 generation，一定能看到对应的 buffer_ 写入
     *   - 与 publish 的 release 形成 synchronizes-with 关系
     *
     * @return 当前的 generation 值
     **************************************************************************/
    inline uint32_t generation() const
    {
        return generation_.load(std::memory_order_acquire);
    }

    /***************************************************************************
     * copy - 拷贝数据到输出参数
     * -------------------------------------------------------------------------
     * 【重要】
     *   调用此函数前，应先通过 generation() 确认有新数据！
     *   否则可能读取到旧数据或正在被写入的数据。
     *
     * 【线程安全】
     *   - 对于小型 POD 类型，通常是安全的
     *   - 对于大型结构体，可能发生"撕裂读取"（读到一半新一半旧的数据）
     *
     * @param out 输出参数，数据将被拷贝到这里
     **************************************************************************/
    inline void copy(T& out) const
    {
        out = buffer_;
    }

    /***************************************************************************
     * register_notifier - 注册 RTOS 通知器
     * -------------------------------------------------------------------------
     * 允许 Topic<T>（只保留最新值）也具备事件驱动唤醒能力。
     * 注意：一个 Topic 目前只保存一个 notifier 指针；如需 fan-out 可用 EventFlags 多 bit 或上层汇聚。
     ***************************************************************************/
    inline void register_notifier(Notifier* n)
    {
        notifier_ = n;
    }

private:
    T buffer_{};                        // 数据缓冲区，存储最新发布的数据
    std::atomic<uint32_t> generation_;  // 版本计数器，每次 publish 后 +1
    Notifier* notifier_{nullptr};       // 可选的事件通知器
};

/*******************************************************************************
 * MultiTopic<T, N> - 多实例主题
 * ----------------------------------------------------------------------------
 *
 * 【功能】
 *   将多个相同类型的 Topic 组织成数组，适用于：
 *   - 多个同类型传感器（如多个 IMU、多个电机）
 *   - 需要通过索引访问的场景
 *
 * 【内部结构】
 *   +--------------------------------------------+
 *   |  MultiTopic<T, N>                          |
 *   |  +--------+--------+--------+--------+     |
 *   |  |Topic[0]|Topic[1]|  ...   |Topic[N-1]    |
 *   |  +--------+--------+--------+--------+     |
 *   +--------------------------------------------+
 *
 * 【使用示例】
 *   // 定义 2 个 IMU 的多实例 Topic
 *   inline MultiTopic<Topic<ImuData>, 2> imu;
 *
 *   // 发布者（IMU 0）
 *   imu[0].publish(imu_data_0);
 *
 *   // 订阅者（订阅 IMU 1）
 *   Subscription<ImuData> sub(imu[1]);
 *
 ******************************************************************************/
template<typename T, int N>
class MultiTopic {
public:
    constexpr MultiTopic() {}

    // 通过索引访问单个 Topic（可修改）
    inline Topic<T>& operator[](int i)
    {
        return topics_[i];
    }

    // 通过索引访问单个 Topic（只读）
    inline const Topic<T>& operator[](int i) const
    {
        return topics_[i];
    }

private:
    Topic<T> topics_[N];  // Topic 数组
};

/*******************************************************************************
 * RingTopic<T, DEPTH> - 环形缓冲主题（带历史记录）
 * ----------------------------------------------------------------------------
 *
 * 【功能】
 *   使用环形缓冲区保存最近 DEPTH 条数据，适用于：
 *   - 需要处理每一条数据（不能丢失）的场景
 *   - 需要访问历史数据的场景
 *   - 生产者和消费者速率不匹配时的缓冲
 *
 * 【内部结构】
 *   +----------------------------------------------------------+
 *   |  RingTopic<T, DEPTH>                                     |
 *   |                                                          |
 *   |  ring_[DEPTH]:  环形缓冲区                                |
 *   |  +------+------+------+------+------+                    |
 *   |  |  D0  |  D1  |  D2  |  D3  | ...  |                    |
 *   |  +------+------+------+------+------+                    |
 *   |          ^                                               |
 *   |          |                                               |
 *   |    write_index_ (下一个写入位置)                          |
 *   |                                                          |
 *   |  generation_: 全局递增序号（每次 publish +1）              |
 *   |  notifier_: 可选的 RTOS 事件通知器                        |
 *   +----------------------------------------------------------+
 *
 * 【写入流程】 (publish)
 *   1. 数据写入 ring_[write_index_]
 *   2. write_index_ = (write_index_ + 1) % DEPTH（循环）
 *   3. generation_.fetch_add(1, release)
 *   4. 如果有 notifier，调用 notify() 唤醒等待的任务
 *
 * 【读取流程】 (copy)
 *   订阅者传入自己上次读到的 generation (gen)：
 *   - 如果 gen == current：无新数据，返回 false
 *   - 如果 current - gen > DEPTH：订阅者太慢，丢失了数据，返回最新的一条
 *   - 否则：根据 delta 计算出历史数据的位置，返回对应数据
 *
 * 【Generation 与 Index 的关系】
 *   假设 DEPTH=4，当前状态：
 *   +-------+-------+-------+-------+
 *   | [0]   | [1]   | [2]   | [3]   |   <- ring_ 数组索引
 *   | gen=5 | gen=6 | gen=7 | gen=4 |   <- 每个位置对应的 generation
 *   +-------+-------+-------+-------+
 *                     ^
 *                     |
 *               write_index_=3, generation_=8 (下一个要写的 gen)
 *
 *   - 最新数据：ring_[(write_index_ + DEPTH - 1) % DEPTH] = ring_[2] (gen=7)
 *   - 订阅者 last_gen=5 想读取 gen=6 的数据：
 *     delta = 8 - 6 = 2
 *     index = (3 + 4 - 2) % 4 = 1  -> ring_[1]
 *
 * 【使用示例】
 *   // 定义带 4 个历史记录的 RingTopic
 *   inline RingTopic<ImuData, 4> imu_ring;
 *
 *   // 发布者
 *   imu_ring.publish(imu_data);
 *
 *   // 订阅者
 *   RingSub<ImuData, 4> sub(imu_ring);
 *   ImuData data;
 *   while (sub.copy(data)) {
 *       // 处理每一条数据（按顺序）
 *   }
 *
 ******************************************************************************/
template<typename T, int DEPTH>
class RingTopic {
public:
    constexpr RingTopic() : write_index_(0), generation_(0) {}

    /***************************************************************************
     * publish - 发布新数据到环形缓冲区
     * -------------------------------------------------------------------------
     * 【执行流程】
     *   1. 将数据写入当前 write_index_ 位置
     *   2. write_index_ 前进一步（循环）
     *   3. generation_ 递增（release 语义）
     *   4. 如果注册了 notifier，发送通知
     *
     * @param data 要发布的数据
     **************************************************************************/
    inline void publish(const T& data)
    {
        ring_[write_index_] = data;                           // Step 1: 写入数据
        write_index_ = (write_index_ + 1) % DEPTH;            // Step 2: 移动写指针
        generation_.fetch_add(1, std::memory_order_release);  // Step 3: 发布（release）

        if (notifier_) {
            notifier_->notify();  // Step 4: 可选的 RTOS 通知
        }
    }

    /***************************************************************************
     * generation - 获取当前版本号
     * -------------------------------------------------------------------------
     * @return 当前的 generation 值（下一个要写入的 generation）
     **************************************************************************/
    inline uint32_t generation() const
    {
        return generation_.load(std::memory_order_acquire);
    }

    /***************************************************************************
     * copy - 根据订阅者的 generation 拷贝对应的数据
     * -------------------------------------------------------------------------
     * 【算法说明】
     *   1. 比较 gen 与 current，判断是否有新数据
     *   2. 计算 delta = current - gen（利用无符号整数的 wrap-around 特性）
     *   3. 如果 delta > DEPTH，说明订阅者太慢，直接返回最新数据
     *   4. 否则，根据 delta 计算出对应的 ring_ 索引
     *
     * 【索引计算】
     *   要读取的数据的 generation = gen
     *   该数据在 ring_ 中的位置：
     *     index = (write_index_ + DEPTH - delta) % DEPTH
     *
     *   解释：
     *   - write_index_ 是下一个要写入的位置
     *   - 最新数据在 (write_index_ - 1 + DEPTH) % DEPTH
     *   - 往前数 delta 个位置就是 gen 对应的数据
     *
     * @param gen 订阅者上次读到的 generation
     * @param out 输出参数
     * @return true 表示成功拷贝了新数据，false 表示无新数据
     **************************************************************************/
    inline bool copy(uint32_t gen, T& out) const
    {
        uint32_t current = generation();

        // 没有新数据
        if (gen == current) {
            return false;
        }

        // 计算差值（无符号减法自动处理溢出）
        uint32_t delta = current - gen;

        if (delta > DEPTH) {
            // 订阅者太慢，丢失了中间数据，返回最新的一条
            // 最新数据在 write_index_ 的前一个位置
            out = ring_[(write_index_ + DEPTH - 1) % DEPTH];
        } else {
            // 正常情况：计算 gen 对应的索引
            uint32_t index = (write_index_ + DEPTH - delta) % DEPTH;
            out = ring_[index];
        }

        return true;
    }

    /***************************************************************************
     * register_notifier - 注册 RTOS 通知器
     * -------------------------------------------------------------------------
     * 【用途】
     *   当新数据发布时，自动通知等待的任务
     *   适用于事件驱动的架构
     *
     * @param n Notifier 指针（生命周期由调用者管理）
     **************************************************************************/
    inline void register_notifier(Notifier* n)
    {
        notifier_ = n;
    }

private:
    T ring_[DEPTH]{};                   // 环形缓冲区
    uint32_t write_index_;              // 下一个写入位置 (0 ~ DEPTH-1)
    std::atomic<uint32_t> generation_;  // 全局递增序号
    Notifier* notifier_{nullptr};       // 可选的事件通知器
};

/*******************************************************************************
 * Subscription<T> - 基于 Topic 的订阅封装（拉取模式）
 * ----------------------------------------------------------------------------
 *
 * 【功能】
 *   封装对 Topic<T> 的订阅，自动追踪读取进度。
 *
 * 【内部状态】
 *   - topic_: 引用被订阅的 Topic
 *   - last_generation_: 上次读取时的 generation
 *
 * 【工作原理】
 *   1. 构造时记录当前 generation 为 last_generation_
 *   2. updated() 比较当前 generation 与 last_generation_
 *   3. copy() 在有新数据时拷贝并更新 last_generation_
 *
 * 【典型使用模式】
 *   // 方式 1：轮询
 *   Subscription<MotorCmd> sub(motor_cmd);
 *   while (true) {
 *       MotorCmd cmd;
 *       if (sub.copy(cmd)) {
 *           // 有新数据，处理 cmd
 *       }
 *       // 做其他事情...
 *   }
 *
 *   // 方式 2：先检查后拷贝
 *   if (sub.updated()) {
 *       MotorCmd cmd;
 *       sub.copy(cmd);
 *       // 处理 cmd
 *   }
 *
 ******************************************************************************/
template<typename T>
class Subscription {
public:
    /***************************************************************************
     * 构造函数
     * -------------------------------------------------------------------------
     * 【行为】
     *   初始化时将 last_generation_ 设为当前 generation
     *   这意味着：订阅者不会收到订阅前已经发布的数据
     *
     * @param topic 要订阅的 Topic 引用
     **************************************************************************/
    explicit Subscription(Topic<T>& topic)
        : topic_(topic)
    {
        last_generation_ = topic_.generation();
    }

    /***************************************************************************
     * updated - 检查是否有新数据
     * -------------------------------------------------------------------------
     * @return true 表示有新数据未读取
     **************************************************************************/
    inline bool updated()
    {
        return topic_.generation() != last_generation_;
    }

    /***************************************************************************
     * copy - 拷贝新数据
     * -------------------------------------------------------------------------
     * 【行为】
     *   1. 检查是否有新数据
     *   2. 如果有，拷贝数据并更新 last_generation_
     *   3. 如果没有，返回 false
     *
     * 【注意】
     *   如果发布者速度很快，可能会跳过中间的一些数据
     *   这对于只关心最新状态的场景是期望的行为
     *
     * @param out 输出参数
     * @return true 表示成功拷贝了新数据
     **************************************************************************/
    inline bool copy(T& out)
    {
        uint32_t gen = topic_.generation();

        if (gen == last_generation_) {
            return false;  // 无新数据
        }

        topic_.copy(out);       // 拷贝数据
        last_generation_ = gen; // 更新已读标记
        return true;
    }

private:
    Topic<T>& topic_;           // 被订阅的 Topic 引用
    uint32_t last_generation_;  // 上次读取的 generation
};

/*******************************************************************************
 * RingSub<T, DEPTH> - 基于 RingTopic 的订阅封装
 * ----------------------------------------------------------------------------
 *
 * 【功能】
 *   封装对 RingTopic 的订阅，支持按顺序读取每一条数据。
 *
 * 【与 Subscription 的区别】
 *   - Subscription: 只关心最新数据，可能跳过中间数据
 *   - RingSub: 按顺序读取，尽量不丢失数据（除非订阅者太慢）
 *
 * 【工作原理】
 *   1. 构造时记录当前 generation
 *   2. 每次 copy() 成功后，last_generation_++（移动到下一条）
 *   3. 如果订阅者太慢（超过 DEPTH），会丢失中间数据
 *
 * 【典型使用模式】
 *   RingSub<ImuData, 4> sub(imu_ring);
 *
 *   // 在任务中循环处理所有未读数据
 *   ImuData data;
 *   while (sub.copy(data)) {
 *       // 按顺序处理每一条 IMU 数据
 *       integrate_imu(data);
 *   }
 *
 ******************************************************************************/
template<typename T, int DEPTH>
class RingSub {
public:
    /***************************************************************************
     * 构造函数
     * -------------------------------------------------------------------------
     * @param topic 要订阅的 RingTopic 引用
     **************************************************************************/
    explicit RingSub(RingTopic<T, DEPTH>& topic)
        : topic_(topic)
    {
        last_generation_ = topic_.generation();
    }

    /***************************************************************************
     * copy - 拷贝下一条未读数据
     * -------------------------------------------------------------------------
     * 【行为】
     *   1. 尝试从 RingTopic 拷贝 last_generation_ 对应的数据
     *   2. 如果成功，last_generation_++
     *   3. 下次调用会尝试读取下一条
     *
     * 【循环读取模式】
     *   while (sub.copy(data)) {
     *       // 每次循环读取一条数据
     *       // 直到没有新数据为止
     *   }
     *
     * @param out 输出参数
     * @return true 表示成功拷贝了数据
     **************************************************************************/
    inline bool copy(T& out)
    {
        uint32_t gen = last_generation_;

        if (!topic_.copy(gen, out)) {
            return false;  // 无新数据
        }

        last_generation_++;  // 移动到下一条
        return true;
    }

private:
    RingTopic<T, DEPTH>& topic_;  // 被订阅的 RingTopic 引用
    uint32_t last_generation_;    // 下一条要读取的 generation
};
